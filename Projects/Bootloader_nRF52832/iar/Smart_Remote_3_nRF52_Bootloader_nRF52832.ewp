# IAR project Smart_Remote_3_nRF52_Bootloader_nRF52832.ewp, settings and files
configuration PCA20023-SR3_nRF52832_Product_Example_Bootloader (ARM)
  General.OGChipSelectEditMenu: nrf52832_xxaa nRF52832_xxAA
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: BLE_STACK_SUPPORT_REQD; CONFIG_BOARD_NRF52832_PCA20023; DFU_APP_DATA_RESERVED=0x2000; FLASH_BUFFER_COUNT=40; FLASH_BUFFER_LENGTH=128; FLOAT_ABI_HARD; NRF52; NRF52832_XXAA; NRF_BOOTLOADER; NRF_DFU_SETTINGS_VERSION=1; NRF_SD_BLE_API_VERSION=5; S132; SOFTDEVICE_PRESENT; SVC_INTERFACE_CALL_AS_NORMAL_FUNCTION; SWI_DISABLE0; __HEAP_SIZE=0
  ICCARM.CCIncludePath2: ..\..\..\Source\Configuration; ..\..\..\Source\Drivers; ..\..\..\..\..\..\components\ble\common; ..\..\..\..\..\..\components\device; ..\..\..\..\..\..\components\drivers_nrf\clock; ..\..\..\..\..\..\components\drivers_nrf\common; ..\..\..\..\..\..\components\drivers_nrf\delay; ..\..\..\..\..\..\components\drivers_nrf\hal; ..\..\..\..\..\..\components\drivers_nrf\rng; ..\..\..\..\..\..\components\drivers_nrf\wdt; ..\..\..\..\..\..\components\libraries\atomic; ..\..\..\..\..\..\components\libraries\atomic_fifo; ..\..\..\..\..\..\components\libraries\balloc; ..\..\..\..\..\..\components\libraries\crc32; ..\..\..\..\..\..\components\libraries\crypto; ..\..\..\..\..\..\components\libraries\crypto\backend\micro_ecc; ..\..\..\..\..\..\components\libraries\crypto\backend\nrf_crypto_sw; ..\..\..\..\..\..\components\libraries\experimental_log; ..\..\..\..\..\..\components\libraries\experimental_log\src; ..\..\..\..\..\..\components\libraries\experimental_memobj; ..\..\..\..\..\..\components\libraries\experimental_section_vars; ..\..\..\..\..\..\components\libraries\fstorage; ..\..\..\..\..\..\components\libraries\hardfault; ..\..\..\..\..\..\components\libraries\hardfault\nrf52; ..\..\..\..\..\..\components\libraries\hci; ..\..\..\..\..\..\components\libraries\mem_manager; ..\..\..\..\..\..\components\libraries\mutex; ..\..\..\..\..\..\components\libraries\pwr_mgmt; ..\..\..\..\..\..\components\libraries\queue; ..\..\..\..\..\..\components\libraries\scheduler; ..\..\..\..\..\..\components\libraries\sha256; ..\..\..\..\..\..\components\libraries\strerror; ..\..\..\..\..\..\components\libraries\svc; ..\..\..\..\..\..\components\libraries\timer; ..\..\..\..\..\..\components\libraries\util; ..\..\..\..\..\..\components\softdevice\common; ..\..\..\..\..\..\components\softdevice\s132\headers; ..\..\..\..\..\..\components\softdevice\s132\headers\nrf52; ..\..\..\..\..\..\components\toolchain; ..\..\..\..\..\..\components\toolchain\cmsis\include; ..\..\..\Source\Bootloader; ..\..\..\Source\Bootloader\bootloader; ..\..\..\Source\Bootloader\bootloader\ble_dfu; ..\..\..\Source\Bootloader\bootloader\dfu; ..\..\..\Source\Bootloader\dfu_req_handling; ..\..\..\..\..\..\external\fprintf; ..\..\..\..\..\..\external\micro-ecc\micro-ecc; ..\..\..\..\..\..\external\nano-pb; ..\..\..\..\..\..\external\segger_rtt; ..\config
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: PCA20023-SR3_nRF52832_Product_Example_Bootloader.hex
  ILINK.IlinkOutputFile: Smart_Remote_3_nRF52_Bootloader_nRF52832.out
  ILINK.IlinkIcfFile: Smart_Remote_3_nRF52_iar_nRF5x.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration PCA63519-SR3_nRF52832_Shield_Bootloader (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: BLE_STACK_SUPPORT_REQD; CONFIG_BOARD_NRF52832_PCA63519; DFU_APP_DATA_RESERVED=0x2000; FLASH_BUFFER_COUNT=40; FLASH_BUFFER_LENGTH=128; FLOAT_ABI_HARD; NRF52; NRF52832_XXAA; NRF_BOOTLOADER; NRF_DFU_SETTINGS_VERSION=1; NRF_SD_BLE_API_VERSION=5; S132; SOFTDEVICE_PRESENT; SVC_INTERFACE_CALL_AS_NORMAL_FUNCTION; SWI_DISABLE0; __HEAP_SIZE=0
  AARM.ADefines: as above
  OBJCOPY.OOCOutputFile: PCA63519-SR3_nRF52832_Shield_Bootloader.hex
  group nRF_Log
    ../../../../../../components/libraries/experimental_log/src/: nrf_log_backend_rtt.c nrf_log_backend_serial.c nrf_log_frontend.c nrf_log_str_formatter.c
  group nano-pb
    ../../../../../../external/nano-pb/: pb_common.c pb_decode.c
  group nRF_Libraries
    ../../../../../../components/libraries/util/: app_error_weak.c app_util_platform.c nrf_assert.c
    ../../../../../../components/libraries/scheduler/: app_scheduler.c
    ../../../../../../components/libraries/timer/: app_timer.c
    ../../../../../../components/libraries/crc32/: crc32.c
    ../../../../../../components/libraries/hardfault/nrf52/handler/: hardfault_handler_iar.c
    ../../../../../../components/libraries/hardfault/: hardfault_implementation.c
    ../../../../../../components/libraries/hci/: hci_mem_pool.c
    ../../../../../../components/libraries/mem_manager/: mem_manager.c
    ../../../../../../components/libraries/atomic_fifo/: nrf_atfifo.c
    ../../../../../../components/libraries/balloc/: nrf_balloc.c
    ../../../../../../external/fprintf/: nrf_fprintf.c nrf_fprintf_format.c
    ../../../../../../components/libraries/fstorage/: nrf_fstorage.c nrf_fstorage_nvmc.c nrf_fstorage_sd.c
    ../../../../../../components/libraries/experimental_memobj/: nrf_memobj.c
    ../../../../../../components/libraries/pwr_mgmt/: nrf_pwr_mgmt.c
    ../../../../../../components/libraries/queue/: nrf_queue.c
    ../../../../../../components/libraries/experimental_section_vars/: nrf_section_iter.c
    ../../../../../../components/libraries/strerror/: nrf_strerror.c
    ../../../../../../components/libraries/sha256/: sha256.c
  group nRF_Drivers
    ../../../../../../components/drivers_nrf/clock/: nrf_drv_clock.c
    ../../../../../../components/drivers_nrf/common/: nrf_drv_common.c
    ../../../../../../components/drivers_nrf/rng/: nrf_drv_rng.c
    ../../../../../../components/drivers_nrf/wdt/: nrf_drv_wdt.c
    ../../../../../../components/drivers_nrf/hal/: nrf_nvmc.c
  group nRF_SoftDevice
    ../../../../../../components/softdevice/common/: nrf_sdh.c nrf_sdh_ble.c nrf_sdh_soc.c
  group nRF_Crypto
    ../../../../../../components/libraries/crypto/: nrf_crypto_ecdh.c nrf_crypto_ecdsa.c nrf_crypto_hash.c nrf_crypto_init.c nrf_crypto_keys.c nrf_crypto_mem.c nrf_crypto_rng.c
  group Application
    ../../../Source/Configuration/: bootloader_key.c sr3_config_nrf52832_pca20023.h sr3_config_nrf52832_pca63519.h
    ../../../Source/Bootloader/dfu_req_handling/: dfu-cc.pb.c dfu_req_handling.c
    ../../../Source/Drivers/: drv_board.c
    ../config/: sdk_config.h
    ../../../Source/Bootloader/: sr3_bootloader.c
  group nRF_micro-ecc
    ../../../../../../external/micro-ecc/nrf52hf_iar/armgcc/: micro_ecc_lib_nrf52.a
  group nRF_Segger_RTT
    ../../../../../../external/segger_rtt/: SEGGER_RTT.c SEGGER_RTT_Syscalls_IAR.c SEGGER_RTT_printf.c
  group nRF_Crypto backends
    ../../../../../../components/libraries/crypto/backend/micro_ecc/: micro_ecc_lib_ecdh.c micro_ecc_lib_ecdsa.c micro_ecc_lib_init.c micro_ecc_lib_keys.c micro_ecc_lib_shared.c
    ../../../../../../components/libraries/crypto/backend/nrf_crypto_sw/: nrf_crypto_sw_hash.c nrf_crypto_sw_rng.c
  group nRF_BLE
    ../../../../../../components/ble/common/: ble_srv_common.c
  group Device
    ../../../../../../components/toolchain/iar/: iar_startup_nrf52.s
    ../../../../../../components/toolchain/: system_nrf52.c
  group nRF_BLE_DFU
    ../../../Source/Bootloader/bootloader/ble_dfu/: nrf_ble_dfu.c
  group nRF_Bootloader
    ../../../Source/Bootloader/bootloader/: nrf_bootloader.c nrf_bootloader_app_start.c nrf_bootloader_app_start_asm.c nrf_bootloader_info.c
    ../../../Source/Bootloader/bootloader/dfu/: nrf_dfu.c nrf_dfu_flash.c nrf_dfu_handling_error.c nrf_dfu_mbr.c nrf_dfu_settings.c nrf_dfu_settings_svci.c nrf_dfu_transport.c nrf_dfu_utils.c
